# Keil uVision project STM32F030.uvprojx, settings and files
target qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\CORE;.\BSP;..\STM32F03x_FWLib\inc;..\STM32F03x_FWLib\src;.\user
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./user/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ./CORE/: startup_stm32f0xx.s
  group SYSTEM
    ./user/: delay.c
  group BSP
    ./BSP/: led.c USART1.c ds18b20.c output.c key.c flash_rw.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_flash.c
software components: CMSIS:CORE 4.3.0
