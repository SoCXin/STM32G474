# Keil uVision project STM32F030.uvprojx, settings and files
target QITAS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00004000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F0XX,USE_STDPERIPH_DRIVER
  c include: ..\CM0;..\user;..\..\STM32F03x_FWLib\inc;..\user\SYS;..\user\SYS\STM32F030;..\user\LED;..\user\GLOBAL
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group user
    ../user/: main.c system_stm32f0xx.c
  group BSP
    ../user/SYS/STM32F030/: sys_stm32f030.c
    ../user/GLOBAL/: global.c
    ../user/LED/: led.c
  group FWLIB
    ../../STM32F03x_FWLib/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c
  group CM0
    ../CM0/: startup_stm32f030x6.s
